# IAR project dummy.ewp, settings and files
configuration Debug ()
